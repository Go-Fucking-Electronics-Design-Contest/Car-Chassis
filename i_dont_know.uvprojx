# Keil uVision project i_dont_know.uvprojx, settings and files
target Car1 (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: i_dont_know +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  c define: __MSPM0G3507__
  c include: .\src\User\Algorithm;.\src\User\Bsp;.\src\User\Core;.\src\User\Function;.\src\User\Task;.\src\User\Test;.\src\User\Generate;.\src\CMSIS\Core\Include;C:\ti\mspm0_sdk_2_05_00_05\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\linker\i_dont_know.sct
  group Algo
    ./src/User/Algorithm/: gravity_kf.c kalman.c mahony.c pid.c
  group Bsp
    ./src/User/Bsp/: icm42688.c power_led.c tb6612.c tjc_uart.c ts_time.c
  group Core
    ./src/User/Core/: flash.c main.c
  group Function
    ./src/User/Function/: imu_calib.c line_sensor.c tjc_protocol.c vofa.c
  group Task
    ./src/User/Task/: car_task.c imu_task.c line_task.c motor_inf_task.c
  group Test
    ./src/User/Test/: test.c
  group Generate
    ./src/User/Generate/: ti_msp_dl_config.c ti_msp_dl_config.h
  group CMSIS
    ./src/CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm0.h core_cm0plus.h mpu_armv7.h
  group Starup
    ./startup/: startup_mspm0g350x_uvision.s
  group DriverLib
    C:/ti/mspm0_sdk_2_05_00_05/source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
